# Copyright © Advanced Micro Devices, Inc., or its affiliates. All rights reserved.
# SPDX-License-Identifier: MIT
# Contributors: KC
# Maintainer: KC

# Provide a default LICENSE so the recipe always parses, even when
# CHROMIUM_PREBUILT != "1" (the prebuilt anonymous python sets LICENSE only in
# that branch). Without this, BitBake halts parsing every layer that includes
# meta-chromium, regardless of whether the target image installs chromium.
LICENSE ?= "CLOSED"

# Chromium expects unversioned Rust stdlib names, but Yocto/Chromium can produce
# hashed files like libfoo-<hash>.rlib in multiple out trees.
CHROMIUM_DEBUG_NINJA_KEEP_GOING ?= "50"

do_compile:prepend() {
    # During debug spins, keep ninja going to surface multiple failures in one run.
    if [ -n "${CHROMIUM_DEBUG_NINJA_KEEP_GOING}" ] && [ "${CHROMIUM_DEBUG_NINJA_KEEP_GOING}" != "0" ]; then
        ninja() {
            command ninja -k "${CHROMIUM_DEBUG_NINJA_KEEP_GOING}" "$@"
        }
    fi

    # Normalize Rust stdlib names (libfoo-<hash>.rlib -> libfoo.rlib) across all
    # generated stdlib trees to avoid per-directory copy failures later in ninja.
    # On clean builds these output dirs may not exist yet, so pre-seed them first.
    for primary_rust_std_dir in         "${B}/obj/build/rust/std/lib"         "${B}/yocto_native/obj/build/rust/std/lib"         "${B}/yocto_native_for_rust_host_build_tools/obj/build/rust/std/lib"; do
        mkdir -p "${primary_rust_std_dir}"
        for rust_seed_dir in ${S}/third_party/rust-toolchain/lib/rustlib/*/lib; do
            [ -d "${rust_seed_dir}" ] || continue
            for hashed in "${rust_seed_dir}"/lib*-*.rlib; do
                [ -e "${hashed}" ] || continue
                base="$(basename "${hashed}")"
                unversioned="${base%-*}.rlib"
                [ "${unversioned}" = "${base}" ] && continue
                if [ ! -e "${primary_rust_std_dir}/${unversioned}" ]; then
                    cp -af "${hashed}" "${primary_rust_std_dir}/${unversioned}"
                fi
            done
        done
    done
    find "${B}" -type d -path "*/obj/build/rust/std/lib" 2>/dev/null | sort -u | while IFS= read -r rust_std_dir; do
        for hashed in "${rust_std_dir}"/lib*-*.rlib; do
            [ -e "${hashed}" ] || continue
            base="$(basename "${hashed}")"
            unversioned="${base%-*}.rlib"
            [ "${unversioned}" = "${base}" ] && continue
            if [ ! -e "${rust_std_dir}/${unversioned}" ]; then
                ln -sf "${base}" "${rust_std_dir}/${unversioned}" 2>/dev/null || cp -af "${hashed}" "${rust_std_dir}/${unversioned}"
            fi
        done

        for rust_seed_dir in ${S}/third_party/rust-toolchain/lib/rustlib/*/lib; do
            [ -d "${rust_seed_dir}" ] || continue
            for hashed in "${rust_seed_dir}"/lib*-*.rlib; do
                [ -e "${hashed}" ] || continue
                base="$(basename "${hashed}")"
                unversioned="${base%-*}.rlib"
                [ "${unversioned}" = "${base}" ] && continue
                if [ ! -e "${rust_std_dir}/${unversioned}" ]; then
                    cp -af "${hashed}" "${rust_std_dir}/${unversioned}"
                fi
            done
        done
    done

    # Rust 1.91 removed no_sanitize; strip stale disable_cfi feature wiring from
    # generated ninja/rsp. These are generated build output, not shipped source,
    # so they are not patched; the crabbyavif crate's own use of the attribute
    # is fixed by SRC_URI patch 0003 instead.
    find "${B}" -type f \( -name "*.ninja" -o -name "*.rsp" \) -exec sed -i 's/ --cfg=feature=\\"disable_cfi\\"//g' {} + 2>/dev/null || true

    latest_inc="${RECIPE_SYSROOT_NATIVE}/usr/lib/clang/latest/include"
    builtin_inc="$(ls -1d ${RECIPE_SYSROOT_NATIVE}/usr/lib/clang/[0-9]*/include 2>/dev/null | sort -V | tail -n1 || true)"
    if [ -d "${latest_inc}" ] && [ -n "${builtin_inc}" ] && [ -d "${builtin_inc}" ]; then
        cp -an "${builtin_inc}/." "${latest_inc}/" || true
    fi

    # Resolve GCC runtime dir from crtbeginS and make linker discovery robust.
    crtbegin="$(find "${RECIPE_SYSROOT}/usr/lib" -type f -name crtbeginS.o 2>/dev/null | sort -V | head -n1 || true)"
    if [ -n "${crtbegin}" ]; then
        gccverdir="$(dirname "${crtbegin}")"

        # Best-effort patch of generated toolchain files (regenerated by GN at
        # reconfigure; the persistent fix is SRC_URI patch 0005).
        sysroot_flag="--sysroot=${RECIPE_SYSROOT}"
        gcc_flags="${sysroot_flag} --gcc-install-dir=${gccverdir} -B${gccverdir} -L${gccverdir}"
        find "${B}" -type f -name toolchain.ninja 2>/dev/null | while IFS= read -r toolchain_ninja; do
            grep -q -- "--gcc-install-dir=" "${toolchain_ninja}" && continue
            sed -i "s|${sysroot_flag}|${gcc_flags}|g" "${toolchain_ninja}"
        done
    fi
}


